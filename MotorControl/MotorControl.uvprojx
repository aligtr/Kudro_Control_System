# Keil uVision project MotorControl.uvprojx, settings and files
target MotorControl (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MotorControl
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\MotorControl;.\Lib\inc;.\Code\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Code
    ./Code/src/: main.c pdu.c callback.c adc.c
  group Lib
    ./Lib/src/: bsp.c delay.c rcc.c MCP.c MotorControl.c encoder.c
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
